# Keil uVision project stm32f10x.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ebox +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: ARM_MATH_CM3
  c include: ..\..\..\mcu\stm32f10x\libraries\CMSIS\CM3\CoreSupport;..\..\..\mcu\stm32f10x\libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\mcu\stm32f10x\libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\mcu\stm32f10x\ebox;..\..\..\mcu\stm32f10x\ebox\core;..\..\..\mcu\stm32f10x\ebox\Peripherals;..\..\..\common\edriver;..\..\..\common\network;..\..\..\common\fat;..\..\..\common\edriver\WiFi;..\..\..\user;..\..\..\common\cJSON;..\..\..\common\edriver\SFUD\sfud\inc;..\..\..\common\edriver\SFUD\ebox;..\..\..\common\bigiot;..\..\..\common\usb_device_stack\USBDevice;..\..\..\common\usb_device_stack\USBHID;..\..\..\common\usb_device_stack\USBAudio;..\..\..\common\usb_device_stack\USBMIDI;..\..\..\common\usb_device_stack\USBMSD;..\..\..\common\usb_device_stack\USBSerial;..\..\..\common\gui;..\..\..\common\FreeModbus\modbus\ascii;..\..\..\common\FreeModbus\modbus\include;..\..\..\common\FreeModbus\modbus\rtu;..\..\..\common\FreeModbus\modbus\tcp;..\..\..\common\FreeModbus\port;..\..\..\common\menu;..\..\..\common\Lora;..\..\..\common\apps;..\..\..\common\DSPLib\Include;..\..\..\common\OSC-master;..\..\..\common\apps\Filters\FirFilter;..\..\..\common\apps\PID\PID;..\..\..\common\apps\PID\PID_AutoTune_v0;..\..\..\core
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group start_code
    ../../../mcu/stm32f10x/libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../../../mcu/stm32f10x/libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../mcu/stm32f10x/libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group libraries
    ../../../mcu/stm32f10x/libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ebox_core
    ../../../core/: new.cpp print.cpp WString.cpp dtostrf.c itoa.c list.cpp ringbuf.cpp util.cpp big_little.cpp ebox_core_.h
    ../../../core/mem/: ebox_mem.c
    ../../../core/math/: random.cpp crc.c LinearRegression.cpp
  group ebox_mcu
    ../../../mcu/stm32f10x/ebox/core/: ebox_common.cpp mcu_core.cpp mcu_mem.c ebox_it.cpp
    ../../../mcu/stm32f10x/ebox/Peripherals/: ebox_analog.cpp ebox_exti.cpp ebox_gpio.cpp ebox_i2c.cpp ebox_iflash.cpp ebox_rtc.cpp ebox_softi2c.cpp ebox_softspi.cpp ebox_spi.cpp ebox_uart.cpp ebox_wdg.cpp ebox_can.cpp ebox_timer.cpp ebox_pwm.cpp ebox_in_capture.cpp ebox_encoder.cpp
    ../../../mcu/stm32f10x/ebox/: object.cpp
  group ebox_apps
    ../../../common/apps/: calendar.cpp color_convert.cpp EventGpio.cpp EventIo.cpp
    ../../../common/apps/Filters/FirFilter/: FirFilter.cpp
    ../../../common/apps/PID/PID/: PID_v1.cpp
  group ebox_driver
    ../../../common/edriver/: 74HC595.cpp at24c02.cpp Button.cpp key_dm.cpp LED.cpp mmc_sd.cpp parallel_gpio.cpp w25x16.cpp ds18b20.cpp si4432.cpp
  group user
    ../../../user/: bsp.cpp main.cpp
  group fat
    ../../../common/fat/: wrapperdiskio.cpp diskio.c ff.c
